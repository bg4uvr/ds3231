# IAR project ds3231.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; USER; STM8S_STDLIB\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ds3231.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: ds3231.out
  group STDLIB
    STM8S_STDLIB/src/: stm8s_exti.c stm8s_gpio.c stm8s_tim4.c
  group USER
    USER/: button.c delay.c ds3231.c ht1621.c key.c led.c main.c myiic.c power.c timer.c
